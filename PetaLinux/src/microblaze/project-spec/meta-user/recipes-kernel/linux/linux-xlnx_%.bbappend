SRC_URI += "file://user.cfg \
            file://axieth.patch \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

