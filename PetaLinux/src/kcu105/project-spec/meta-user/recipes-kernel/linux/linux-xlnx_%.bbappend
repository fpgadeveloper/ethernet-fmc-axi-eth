SRC_URI += "file://user.cfg \
            file://axieth.patch \
            file://kcu105.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

