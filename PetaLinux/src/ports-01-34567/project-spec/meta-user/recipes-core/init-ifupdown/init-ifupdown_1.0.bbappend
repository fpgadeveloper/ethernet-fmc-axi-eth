FILESEXTRAPATHS_prepend := "${THISDIR}/init-ifupdown-1.0:"

